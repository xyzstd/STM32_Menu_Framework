# Keil uVision project Project.uvprojx, settings and files
target Debug-Sim (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08008000,0x00036800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SolderingIron-SIM.hex +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HW_SIM_MODE=1
  c include: .\bsp;.\package;.\start;.\page;.\ctrl;.\menu;.\sys;.\main;.\ota\app_side
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x36800
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6305
  group start
    ./start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group ota_app_side
    ./ota/app_side/: ota_boot.c ota_boot.h ota_config.h
  group package
    ./package/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group sys
    ./sys/: delay.c delay.h timer.c timer.h
  group bsp
    ./bsp/: adc.c adc.h config.c config.h encoder.c encoder.h flash.c flash.h key.c key.h oled.c oled.h oled_data.c oled_data.h pwm.c pwm.h serial.c serial.h buzzer.c buzzer.h
  group menu
    ./menu/: menu.c menu.h menu_table.c menu_anim.c menu_anim.h menu_display.c menu_display.h
  group page
    ./page/: home.c home.h ota_wait.c ota_wait.h temp.c temp.h toast.c toast.h pid.c pid.h calibrate.c calibrate.h autotune.c autotune.h cur_cal.c cur_cal.h settings.c settings.h handle.c handle.h confirm.c confirm.h param.c param.h
    ./ctrl/: pid_controller.c pid_controller.h heater.c heater.h
  group main
    ./main/: main.c input.c input.h ui_task.c ui_task.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h work_task.c work_task.h
target Release-HW (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: SolderingIron-HW.hex +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HW_SIM_MODE=0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x36800
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6305
